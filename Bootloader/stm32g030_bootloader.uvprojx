# Keil uVision project stm32g030_bootloader.uvprojx, settings and files
target STM32G030F6P6 (6240000::V6.24::ARMCLANG)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: stm32g030_bootloader
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group inc
    ./: flash.h app_image.h
  group src
    ./: main.c flash.c app_image.c
  group Device
    ./RTE/_STM32G030F6P6/: startup_stm32g030xx.s system_stm32g0xx.c
software components: CMSIS:CORE 6.2.0
